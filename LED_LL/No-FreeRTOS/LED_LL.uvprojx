# Keil uVision project LED_LL.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED_LL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103x6,USE_FULL_LL_DRIVER
  c include: ..\No-FreeRTOS;..\User;..\..\Drivers\CMSIS\Device\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ./: main.c
    ../User/: stm32f1xx_it.c led.c mco.c
  group CMSIS
    ../../Drivers/CMSIS/Device/Source/: system_stm32f1xx.c
    ../../Drivers/CMSIS/Device/Source/arm/: startup_stm32f103x6.s
  group STM32F1xx_LL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_ll_utils.c stm32f1xx_ll_rcc.c
