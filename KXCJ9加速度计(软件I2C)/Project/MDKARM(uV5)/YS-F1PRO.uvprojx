# Keil uVision project YS-F1PRO.uvprojx, settings and files
target YS-F1PRO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YS-F1PRO +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\..\Device\Core;..\..\..\Device\Include;..\..\..\Device\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../../../Device/Source/ARM/: startup_stm32f10x_hd.s
  group CMSIS
    ../../../Device/Source/: system_stm32f10x.c
  group StdPeriph_Derive
    ../../../Device/StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c
  group User
    ../../User/: main.c stm32f10x_it.c
  group bsp
    ../../User/bsp/usart/: bsp_debug_usart.c
    ../../User/bsp/I2C/: bsp_i2c.c
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/systick/: bsp_SysTick.c
    ../../User/bsp/kxcj9/: kxcj9.c
