# Keil uVision project BDCMotor.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BDCMotor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\..\Device\Core;..\..\Device\Include;..\..\Device\StdPeriph_Driver\inc;..\No-FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c
    ../User/: led.c stm32f10x_it.c BDCMotor.c key.c delay.c usart2.c Encoder.c lcd.c
  group Startup
    ../../Device/Source/: system_stm32f10x.c
    ../../Device/Source/ARM/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Device/StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c
