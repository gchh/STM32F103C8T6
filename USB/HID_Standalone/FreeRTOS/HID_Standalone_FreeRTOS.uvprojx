# Keil uVision project HID_Standalone_FreeRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HID_Standalone_FreeRTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103x6,RTE_CMSIS_RTOS_RTX
  c include: ..\FreeRTOS;..\User;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\Include;..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\Drivers\STM32_USB_Device_Library\Class\HID\Inc;..\..\..\Drivers\STM32_USB_Device_Library\Core\Inc;..\..\..\FreeRTOS\Source\include;..\..\..\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c
    ../User/: led.c mco.c stm32f1xx_it.c usbd_conf.c usbd_desc.c
  group CMSIS
    ../../../Drivers/CMSIS/Device/Source/: system_stm32f1xx.c
    ../../../Drivers/CMSIS/Device/Source/arm/: startup_stm32f103x6.s
  group STM32F1xx_HAL_Driver
    ../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_usb.c
  group USB_LIB_HID
    ../../../Drivers/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group USB_LIB_Core
    ../../../Drivers/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group FreeRTOS
    ../../../FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
